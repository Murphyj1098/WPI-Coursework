options:
  parameters:
    generate_options: no_gui
    id: top_block
    max_nouts: ''
    output_language: python
    title: Spectrum Analyzer
  states: {}

blocks:
- name: mqp_get
  id: variable
  parameters:
    value: 900e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(300e3)
  states: {}
- name: blocks_file_meta_sink_0
  id: blocks_file_meta_sink
  parameters:
    detached: 'False'
    extra_dict: pmt.make_dict()
    file: /home/jrmurphy/Desktop/sample.dat
    max_seg_size: '1000'
    rel_rate: '1'
    samp_rate: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: /home/jrmurphy/Desktop/sample.dat
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import pmt
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: samp_rate
    center_freq0: mqp_get
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: '28'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    stream_args: peak=0.003906
    sync: none
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:7000
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_meta_sink_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_file_sink_0, '0']
- [blocks_vector_to_stream_0, '0', zeromq_push_sink_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
